# Keil uVision project 全功能测试.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 全功能测试 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c main.h decoder.c decoder.h sys.h sys.c led.h led.c seg.h seg.c key.h key.c appled.h appled.c appseg.h appseg.c appkey.h appkey.c y5driver.h y5driver.c
