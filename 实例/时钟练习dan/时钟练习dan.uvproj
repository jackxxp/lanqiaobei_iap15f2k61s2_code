# Keil uVision project 时钟练习dan.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 时钟练习dan +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.h sys_main.h sys_task.h app_main.h drv_led.h drv_seg.h drv_other.h drv_key.h drv_rtc.h drv_temp.h main.c sys_main.c sys_task.c app_main.c drv_led.c drv_seg.c drv_other.c drv_key.c drv_rtc.c drv_temp.c
