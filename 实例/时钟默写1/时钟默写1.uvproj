# Keil uVision project 时钟默写1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 时钟默写1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 app_main.c app_main.h drv_key.c drv_key.h drv_led.c drv_led.h drv_other.c drv_other.h drv_rtc.c drv_rtc.h drv_seg.c drv_seg.h sys_task.h sys_task.c sys_main.h sys_main.c main.h main.c drv_temp.h drv_temp.c
