# Keil uVision project 十四届v2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 十四届v2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c main.h sys.c sys.h app.h app.c led.h led.c seg.h seg.c key.h key.c rtc.h rtc.c ne555.h ne555.c i2c.h i2c.c temp.h temp.c
