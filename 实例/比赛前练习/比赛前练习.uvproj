# Keil uVision project 比赛前练习.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 比赛前练习 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.h main.c sys_main.h sys_main.c sys_task.h sys_task.c app_main.h app_main.c drv_led.c drv_led.h
