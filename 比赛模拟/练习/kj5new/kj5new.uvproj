# Keil uVision project kj5new.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: kj5 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c sys.h sys.c app.c app.h seg.h seg.c led.h led.c otr.h otr.c fre.h fre.c key.h key.c rtc.h rtc.c dis.h dis.c temp.h temp.c iic.h iic.c pwm.h pwm.c uart.h uart.c
